# Autodesk Inventor part: 8CMA06-13-15
## iProperties
Created: 2008-09
Part Number: 8CMA06-13-15
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
